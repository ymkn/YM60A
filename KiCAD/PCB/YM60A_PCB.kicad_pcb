# Repository ymkn/YM60A

File README.md:

# YM60A

An ANSI-style layout for use on Japanese 106/109 layouts 60% hot swappable custom mechanical keyboard PCB powered by RP2040. Suitable for most Poker-compatible 60% keyboard cases.

## Default Layout

You can customize the layout with [Vial](https://get.vial.today/) configurator.

Spacebar can be swap 3u to 2.25/2.75u with 2u stabilizers if you don't have 3u spacebar and its stabilizers.

## Specification

- MX compatible switches
- USB-C Connector (USB 2.0)
- Hot swappable
- Dimension: 285mm(w) x 94.6mm(h) x 1.6mm(d)
- Suitable for most 60% keyboard cases
  - Warning: center and right bottom mounting holes are not implemented.

## Build Guide

See [doc/buildguide.md](doc/buildguide.md)

## LICENSE

This project is licensed under the MIT License, see the [LICENSE file](LICENSE) for details.

## KiCad design KiCAD/PCB/YM60A_PCB.kicad_pcb

Parts:
BTN1: TS-1187A-B-A-B; SW_Push_1P1T_XKB_TS-1187A; LCSC Parts # C318884
C1, C2: 10uF; C_0402_1005Metric; LCSC Parts # C15525
C3, C4, C5, C6, C7, C8, C9, C10, C13, C16, C17: 100nF; C_0402_1005Metric; LCSC Parts # C1525
C11, C12: 1uF; C_0402_1005Metric; LCSC Parts # C52923
C14, C15: 20pF; C_0402_1005Metric; LCSC Parts # C1554
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D61, D62, D63, D64, D65, D66, D67: 1N4148W; D_SOD-123; LCSC Parts # C81598
J1: TYPE-C-31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC Parts # C165948
R1, R3: 5.1K; R_0402_1005Metric; LCSC Parts # C25905
R4, R5: 27; R_0603_1608Metric; LCSC Parts # C13167
R6: 1KΩ; R_0402_1005Metric; LCSC Parts # C11702
R7: 10kΩ; R_0402_1005Metric; LCSC Parts # C25744
R8: 1K; R_0402_1005Metric; LCSC Parts # C11702
SW1, SW4, SW6, SW7, SW8, SW9, SW11, SW12, SW13, SW14, SW16, SW17, SW18, SW19, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW43, SW44, SW45, SW46, SW48, SW49, SW50, SW51, SW53, SW54, SW55, SW56, SW57, SW58, SW59, SW61, SW62, SW66, SW67: SW_Push; SW_MX_HS_CPG151101S11_1u
SW2, SW5: SW_Push; SW_MX_HS_CPG151101S11_1.5u
SW3: SW_Push; SW_MX_HS_CPG151101S11_1.75u
SW10, SW15, SW20, SW42, SW47, SW52: SW_Push; SW_MX_HS_CPG151101S11_1.25u
SW29: Space; SW_MX_HS_CPG151101S11_1u
SW63: Backspace; SW_MX_HS_CPG151101S11_1u
SW64: Backslash; SW_MX_HS_CPG151101S11_1.5u
SW65: Enter; SW_MX_HS_CPG151101S11_1u
U1: XC6206P332MR; SOT-23-3; LCSC Parts # C5446
U2: SMF05CT1G; SOT-363-6_2P2X1P35_ONS; LCSC Parts # C15879
U3: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; LCSC Parts # C2040
U4: W25Q16JVUXIQ; W25Q16JVUXIQ_WIN; LCSC Parts # C2843335
Y1: X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC Parts # C9002

Connections:
+1V1: C3.1, C4.1, C11.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+3V3: C2.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C12.1, C13.1, C16.1, C17.1, R7.2, U1.2 (VO), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.26 (RUN), U3.33 (IOVDD), U3.42 (IOVDD), U3.43 (ADC_AVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD), U4.8 (VCC)
+5V: C1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.3 (VI), U2.4 (CATHODE)
BOOT: BTN1.2, R6.2
COL0: SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, U3.18 (GPIO15)
COL1: SW6.1, SW7.1, SW8.1, SW9.1, SW10.1, U3.3 (GPIO1)
COL2: SW11.1, SW12.1, SW13.1, SW14.1, SW15.1, U3.4 (GPIO2)
COL3: SW16.1, SW17.1, SW18.1, SW19.1, SW20.1, U3.5 (GPIO3)
COL4: SW21.1, SW22.1, SW23.1, SW24.1, U3.6 (GPIO4)
COL5: SW25.1, SW26.1, SW27.1, SW28.1, SW29.1, U3.7 (GPIO5)
COL6: SW30.1, SW31.1, SW32.1, SW33.1, U3.8 (GPIO6)
COL7: SW34.1, SW35.1, SW36.1, SW37.1, U3.9 (GPIO7)
COL8: SW38.1, SW39.1, SW40.1, SW41.1, SW42.1, U3.11 (GPIO8)
COL9: SW43.1, SW44.1, SW45.1, SW46.1, SW47.1, U3.12 (GPIO9)
COL10: SW48.1, SW49.1, SW50.1, SW51.1, SW52.1, U3.14 (GPIO11)
COL11: SW53.1, SW54.1, SW55.1, SW56.1, SW57.1, U3.15 (GPIO12)
COL12: SW58.1, SW59.1, SW61.1, SW62.1, U3.16 (GPIO13)
COL13: SW63.1, SW64.1, SW65.1, SW66.1, SW67.1, U3.17 (GPIO14)
GND: BTN1.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.1, C16.2, C17.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R1.2, R3.1, U1.1 (GND), U2.2 (ANODE), U3.19 (TESTEN), U3.57 (GND), U4.4 (GND), U4.9 (EPAD), Y1.2, Y1.4
unnamed: C15.2, R8.1, Y1.3
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW48.2
unnamed: D49.2 (A), SW49.2
unnamed: D50.2 (A), SW50.2
unnamed: D51.2 (A), SW51.2
unnamed: D52.2 (A), SW52.2
unnamed: D53.2 (A), SW53.2
unnamed: D54.2 (A), SW54.2
unnamed: D55.2 (A), SW55.2
unnamed: D56.2 (A), SW56.2
unnamed: D57.2 (A), SW57.2
unnamed: D58.2 (A), SW58.2
unnamed: D59.2 (A), SW59.2
unnamed: D61.2 (A), SW61.2
unnamed: D62.2 (A), SW62.2
unnamed: D63.2 (A), SW63.2
unnamed: D64.2 (A), SW64.2
unnamed: D65.2 (A), SW65.2
unnamed: D66.2 (A), SW66.2
unnamed: D67.2 (A), SW67.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R3.2
unnamed: R5.2, U3.46 (USB_DM)
unnamed: R4.2, U3.47 (USB_DP)
QSPI_SCLK: U3.52 (QSPI_SCLK), U4.6 (CLK)
QSPI_SD0: U3.53 (QSPI_SD0), U4.5 (DI(IO0))
QSPI_SD1: U3.55 (QSPI_SD1), U4.2 (DO(IO1))
QSPI_SD2: U3.54 (QSPI_SD2), U4.3 (/WP(IO2))
QSPI_SD3: U3.51 (QSPI_SD3), U4.7 (/HOLD_or_/RESET(IO3))
QSPI_SS: R6.1, R7.1, U3.56 (QSPI_SS), U4.1 (/CS)
ROW0: D1.1 (K), D6.1 (K), D11.1 (K), D16.1 (K), D21.1 (K), D25.1 (K), D30.1 (K), D34.1 (K), D38.1 (K), D43.1 (K), D48.1 (K), D53.1 (K), D58.1 (K), D63.1 (K), U3.32 (GPIO21)
ROW1: D2.1 (K), D7.1 (K), D12.1 (K), D17.1 (K), D22.1 (K), D26.1 (K), D31.1 (K), D35.1 (K), D39.1 (K), D44.1 (K), D49.1 (K), D54.1 (K), D59.1 (K), D64.1 (K), U3.34 (GPIO22)
ROW2: D3.1 (K), D8.1 (K), D13.1 (K), D18.1 (K), D23.1 (K), D27.1 (K), D32.1 (K), D36.1 (K), D40.1 (K), D45.1 (K), D50.1 (K), D55.1 (K), D65.1 (K), U3.29 (GPIO18)
ROW3: D4.1 (K), D9.1 (K), D14.1 (K), D19.1 (K), D24.1 (K), D28.1 (K), D33.1 (K), D37.1 (K), D41.1 (K), D46.1 (K), D51.1 (K), D56.1 (K), D61.1 (K), D66.1 (K), U3.30 (GPIO19)
ROW4: D5.1 (K), D10.1 (K), D15.1 (K), D20.1 (K), D29.1 (K), D42.1 (K), D47.1 (K), D52.1 (K), D57.1 (K), D62.1 (K), D67.1 (K), U3.31 (GPIO20)
USB_D+: J1.A6 (D+), J1.B6 (D+), R4.1, U2.3 (CATHODE), U2.5 (CATHODE)
USB_D-: J1.A7 (D-), J1.B7 (D-), R5.1, U2.1 (CATHODE), U2.6 (CATHODE)
XIN: C14.2, U3.20 (XIN), Y1.1
XOUT: R8.2, U3.21 (XOUT)

Notes on the sheet:
※RP2040近傍
Flash
Key Matrix
※リセットボタン実装無し
USB / Power
※WS25Q16JV近傍
※USBコネクタ近傍
※差動信号、配線長さ合わせる
※VREG_IN近傍
Boot / Reset Buttons
MCU
※3.3V電源ピン近傍
※RP2040近傍配置/直結
※VREG_VOUT近傍
Crystal
※以前はここにRESETボタンの回路があった。 基板スペースと費用の都合で削除した。

Board: 2 copper layers, 285.1 x 94.6 mm, 163 parts (163 on the bottom side), 105 nets.

File KiCAD/PCB/production/YM60A_PCB_v1.0/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BTN1,SW_Push_1P1T_XKB_TS-1187A,1,TS-1187A-B-A-B,
"C1, C2",0402,2,10uF,
"C10, C13, C16, C17, C3, C4, C5, C6, C7, C8, C9",0402,11,100nF,
"C11, C12",0402,2,1uF,
"C14, C15",0402,2,20pF,
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D3, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D4, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D5, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D6, D61, D62, D63, D64, D65, D66, D67, D7, D8, D9",D_SOD-123,66,1N4148W,
J1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,TYPE-C-31-M-12,
"R1, R3",0402,2,5.1K,
"R4, R5",0603,2,27,
R6,0402,1,1KΩ,
R7,0402,1,10kΩ,
R8,0402,1,1K,
U1,SOT-23-3,1,XC6206P332MR,
U2,SOT-363-6_2P2X1P35_ONS,1,SMF05CT1G,
U3,QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm,1,RP2040,
U4,W25Q16JVUXIQ_WIN,1,W25Q16JVUXIQ,
Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,X322512MSB4SI,

## Commit log

2024-03-21 v1.0
2024-03-24 ビルドガイドの追加
2024-07-16 v1.0.1
2024-07-16 スイッチパッド設計データ追加
2024-07-16 ビルドガイドにスイッチパッドセットに関する記述を追加
2024-09-01 画像抜けを更新
2024-09-01 基板厚みの誤記を修正
